# Repository ararobo/md-01

## EAGLE design md-01.brd

Parts:
C1, C3, C7: 0.1u; C0603
C2: 10u; C0805
C4, C5, C6, C8, C9, C10: 0.22u; C2012
JP1: PINHD-2X4/90; 2X04/90
JP2: PINHD-2X13/90; 2X13/90
LED1, LED2, LED7, LED8: LED_CHIP_GREEN-1608; LEDC1608X39N_G
R1, R4, R7, R8, R10, R12, R14, R15, R17, R19: 10k; R0603
R2, R5: 1k; R0603
R9, R11, R13, R16: 10; R0603
U$1, U$6: ＩＲ２１０４ＳＴＲＰＢＦ; SOIC-8
U$2, U$3: ＧＳ１０１０ＦＬ; DIODE_SOD-123FL
U$4, U$7, U$8, U$10: SQM50034EL_GE3; TO-263/D2PAK
U$5, U$9: PV-3
U$11, U$12: ＴＬＰ２９３（ＧＢ）; MINI-FLAT-4
U$13: NJM78L05SU3; SOT-89

Connections:
5V: C1.2, R19.2, U$11.IN1, U$12.IN1, U$13.1 (OUT)
GND: C1.1, C2.2, C3.1, C7.1, JP2.1, JP2.2, JP2.3, JP2.4, JP2.5, JP2.6, JP2.7, JP2.8, JP2.9, JP2.10, JP2.11, JP2.12, LED7.1 (C), LED8.1 (C), R7.2, R8.2, R12.1, R15.1, U$1.4 (COM), U$4.S, U$6.4 (COM), U$8.S, U$13.2 (GND), U$13.4 (GND)
GND1: JP1.1, JP1.2, JP1.3, JP1.4, JP1.5, JP1.6, LED1.1 (C), LED2.1 (C), U$11.GND1, U$12.GND1
HOA: R9.1, U$6.7 (HO)
HOB: R13.1, U$1.7 (HO)
LOA: R11.1, U$6.5 (LO)
LOB: R16.1, U$1.5 (LO)
MD1A: JP1.7, R4.1, R5.1
MD1B: JP1.8, R1.1, R2.1
unnamed: R15.2, R16.2, U$8.G
unnamed: R11.2, R12.2, U$4.G
unnamed: LED1.2 (A), R1.2
unnamed: R5.2, U$11.IN
unnamed: R2.2, U$12.IN
unnamed: LED2.2 (A), R4.2
unnamed: R13.2, R14.2, U$7.G
unnamed: C8.1, C9.1, C10.1, U$1.8 (VB), U$3.C
unnamed: R9.2, R10.2, U$10.G
unnamed: LED7.2 (A), R17.1
unnamed: LED8.2 (A), R19.1
unnamed: C4.1, C5.1, C6.1, U$2.C, U$6.8 (VB)
PWMA: R8.1, U$6.2 (IN), U$11.OUT1
PWMB: R7.1, U$1.2 (IN), U$12.OUT1
SA: C4.2, C5.2, C6.2, R10.1, U$4.D, U$6.6 (VS), U$9.P$1, U$10.S
SB: C8.2, C9.2, C10.2, R14.1, U$1.6 (VS), U$5.P$1, U$7.S, U$8.D
VCC: C2.1, C3.2, C7.2, JP2.13, JP2.14, JP2.15, JP2.16, JP2.17, JP2.18, JP2.19, JP2.20, JP2.21, JP2.22, JP2.23, JP2.24, JP2.25, JP2.26, R17.2, U$1.1 (VCC), U$1.3 (SD), U$2.A, U$3.A, U$6.1 (VCC), U$6.3 (SD), U$7.D, U$10.D, U$13.3 (IN)

Notes on the sheet:
モタドラ
C2とC18は
ブートストラップ用のコンデンサー

Board: 2 copper layers, 80.0 x 62.0 mm, 45 parts (13 on the bottom side), 26 nets.
